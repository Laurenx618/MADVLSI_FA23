** sch_path: MP1/xschem/AND.sch
**.subckt AND VP VN A B Y
*.iopin VP
*.iopin VN
*.ipin A
*.ipin B
*.opin Y
X1 A B net1 VP VN NAND
X2 net1 Y VP VN inverter
**.ends
.end

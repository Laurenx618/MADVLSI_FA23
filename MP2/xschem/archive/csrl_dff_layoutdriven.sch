v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/ipin.sym} 80 170 0 0 {name=p1 lab=D}
C {devices/ipin.sym} 80 220 0 0 {name=p2 lab=DB}
C {devices/iopin.sym} 80 120 2 0 {name=p4 lab=VP}
C {devices/iopin.sym} 80 330 2 0 {name=p5 lab=VN}
C {devices/ipin.sym} 80 280 0 0 {name=p7 lab=CLK}
C {devices/opin.sym} 750 210 0 0 {name=p6 lab=QB}
C {devices/opin.sym} 750 120 0 0 {name=p3 lab=Q}
